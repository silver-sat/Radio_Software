options:
  parameters:
    generate_options: qt_gui
    id: sa1
    output_language: python
    thread_safe_setters: '1'
    title: silversat receiver
  states: {}

blocks:
- name: TED_bandwidth
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: decimation
  id: variable_qtgui_range
  parameters:
    gui_hint: 'display@0: 0, 1, 1, 1'
    label: decimation
    min_len: '100'
    start: '1'
    step: '1'
    stop: '50'
    value: '40'
    widget: counter
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: symbol_rate/2*0.67
  states: {}
- name: offset_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 'display@0: 0, 0, 1, 1'
    min_len: '100'
    start: '-10000'
    step: '100'
    stop: '10000'
    value: '5300'
    widget: counter
  states: {}
- name: pkt_len
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 'display@0: 0, 2, 1, 1'
    min_len: '100'
    start: '-100'
    step: '1'
    stop: '0'
    value: '-43'
    widget: counter
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: symbol_sample_rate
  id: variable
  parameters:
    value: symbol_rate*samples_per_symbol
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '.1'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/decimation/(2*pi*fsk_deviation_hz)
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    comment: Rename file if you want to save data between runs
    file: /home/tom/stream.hex
    type: byte
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: pkt_len
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      This and the next block are equivalent
      to the Frequency Translating FIR filter
      but broken down so I could verify it was 
      working correctly
    phase_inc: 2*pi/samp_rate
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: command_byte
  id: satellites_pdu_head_tail
  parameters:
    comment: Command byte
    mode: '0'
    num: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010101010101010101000110011010101010011001101010101'
    comment: |-
      Looks for a AAAAAA33553355 
      with up to 4 errors
    tagname: ss_packet
    threshold: '4'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: TED_bandwidth
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '0.05'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: display
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Stock low pass filter, nothing optimized
    decim: decimation
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transition_bw)
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_frequency+offset_frequency
    decim: decimation
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: 32768*64
    comment: Frequency offsets are handled here
    filter_source: '''Auto'''
    frequency: center_frequency+offset_frequency
    gain1: '''manual'''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: il2p_frame_sync
  id: satellites_pdu_head_tail
  parameters:
    comment: IL2P Frame Sync
    mode: '0'
    num: '3'
  states: {}
- name: il2p_header
  id: satellites_pdu_head_tail
  parameters:
    comment: IL2P Header
    mode: '0'
    num: '13'
  states: {}
- name: il2p_parity
  id: satellites_pdu_head_tail
  parameters:
    comment: IL2P Header Parity
    mode: '2'
    num: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: pack_length
  id: satellites_pdu_head_tail
  parameters:
    comment: Length byte
    mode: '0'
    num: '1'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'display@0: 2, 1, 1,1'
    legend: 'False'
    samp_per_symbol: '8'
    size: '128'
    srate: symbol_sample_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'display@0: 1, 0, 1,1'
    legend: 'False'
    name: Input
    showports: 'True'
    tr_level: '-40'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.005'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'display@0: 1, 1, 1, 1'
    legend: 'False'
    name: Translated
    showports: 'True'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: complex
    update_time: '0.005'
    ymax: '0'
    ymin: '-130'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'display@0: 1, 2, 1, 1'
    legend: 'False'
    name: demod out
    size: 256*6*8
    srate: symbol_sample_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'display@0: 2, 2, 1,1'
    legend: 'False'
    name: slicer out
    size: '512'
    srate: symbol_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'display@0: 2, 0, 1,1'
    label1: clock
    label2: symbol sync
    legend: 'False'
    name: symbol sync
    nconnections: '2'
    size: '512'
    srate: symbol_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    int_max: '-40'
    int_min: '-100'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_frequency
    fftsize: '1024'
    int_max: '-40'
    int_min: '-100'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimation)
    fbw: '0.4'
    interp: samples_per_symbol*symbol_rate
    taps: ''
    type: fff
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_2
  id: satellites_sync_to_pdu_packed
  parameters:
    comment: This is the beginning of the packet dissector flow
    packlen: '239'
    sync: '''10101010101010101010101000110011010101010011001101010101'''
    threshold: '4'
  states: {}
- name: satellites_varlen_packet_tagger_0
  id: satellites_varlen_packet_tagger
  parameters:
    comment: Extracts packets based on the length byte
    endianness: gr.GR_MSB_FIRST
    length_field_size: '8'
    mtu: 239*8
    packetlen_tag: packet_len
    syncword_tag: ss_packet
    use_golay: 'False'
  states: {}
- name: ss_header
  id: satellites_pdu_head_tail
  parameters:
    comment: |-
      Packet Header including 
      AX5043 fields
    mode: '0'
    num: '20'
  states: {}
- name: ss_header_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '2'
    num: '19'
  states: {}
- name: ss_header_0_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '2'
    num: '18'
  states: {}
- name: ss_header_0_0_0
  id: satellites_pdu_head_tail
  parameters:
    mode: '2'
    num: '15'
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_rotator_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [command_byte, out, satellites_hexdump_sink_0, in]
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_2, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_varlen_packet_tagger_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_eye_sink_x_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [digital_symbol_sync_xx_1, '1', qtgui_time_sink_x_1_0_0, '1']
- [fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_rotator_cc_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [il2p_frame_sync, out, satellites_hexdump_sink_0, in]
- [il2p_header, out, satellites_hexdump_sink_0, in]
- [il2p_parity, out, satellites_hexdump_sink_0, in]
- [pack_length, out, blocks_msgpair_to_var_0, inpair]
- [pack_length, out, satellites_hexdump_sink_0, in]
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_sync_to_pdu_packed_2, out, ss_header, in]
- [satellites_varlen_packet_tagger_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [ss_header, out, pack_length, in]
- [ss_header, out, ss_header_0, in]
- [ss_header_0, out, command_byte, in]
- [ss_header_0, out, ss_header_0_0, in]
- [ss_header_0_0, out, il2p_frame_sync, in]
- [ss_header_0_0, out, ss_header_0_0_0, in]
- [ss_header_0_0_0, out, il2p_header, in]
- [ss_header_0_0_0, out, il2p_parity, in]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
