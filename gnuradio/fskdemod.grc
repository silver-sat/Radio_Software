options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: options_0
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: averages
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433.00e6+offset_frequency*1e3
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 3.2e3
  states: {}
- name: offset_frequency
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '0.5'
    stop: '100'
    value: '-0.5'
  states: {}
- name: perceived_freq
  id: variable
  parameters:
    value: 423*samp_rate-center_freq
  states: {}
- name: rx_bw
  id: variable
  parameters:
    value: 2*(fsk_deviation_hz+baud_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '6'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    start: '-80'
    step: '1'
    stop: '0'
    value: '-43'
  states: {}
- name: symbol_sample_rate
  id: variable
  parameters:
    value: baud_rate*samples_per_symbol
  states: {}
- name: transition_bw
  id: variable_qtgui_range
  parameters:
    start: baud_rate/20
    step: baud_rate/20
    stop: baud_rate/2
    value: baud_rate/12
  states: {}
- name: variable_header_format_default_0
  id: variable_header_format_default
  parameters:
    access_code: '0'
    bps: '1'
    threshold: '0'
  states: {state: disabled}
- name: variable_header_format_default_1
  id: variable_header_format_default
  parameters:
    access_code: '1010101010101010101010101010101000100010011001100010001001100110'
    bps: '1'
    threshold: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: averages/100
    gate: 'False'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samples_per_symbol*baud_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sync_out.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: tagged_data.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: slicer_out.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: data_data.dat
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: header
    type: byte
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '0'
    sps: '6'
    symbols: '10001001100110001000100110011'
    threshold: '0.8'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010101010101010101010101010101000100010011001100010001001100110'
    tagname: '''header'''
    threshold: '0'
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '64'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"frame_len"'
    output_symbols: 'False'
    samp_rate: baud_rate
    special_tags: '""'
    timing_tag_key: '"rx_time"'
    type: byte
  states: {state: disabled}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: variable_header_format_default_1
  states: {state: disabled}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: header_format
  states: {state: disabled}
- name: digital_protocol_parser_b_1
  id: digital_protocol_parser_b
  parameters:
    format: variable_header_format_default_1
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: samples_per_symbol
    ted_gain: '1'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center_freq
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.band_pass(1.0, samp_rate, perceived_freq-rx_bw/2, perceived_freq+rx_bw/2 , transition_bw)
    type: ccf
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    legend: 'False'
    samp_per_symbol: samples_per_symbol
    size: '1024'
    srate: samples_per_symbol*baud_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    tr_level: '-50'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate/decimation
    fc: perceived_freq
    fftsize: '1024'
    grid: 'True'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"demod out"'
    size: '1024'
    srate: samples_per_symbol*baud_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    label3: ''
    name: '"aligned data"'
    nconnections: '3'
    size: '256'
    srate: baud_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"data correlation"'
    size: '1024'
    srate: 6*baud_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"correlation"'
    size: '1024'
    srate: 6*baud_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/decimation)
    fbw: '0.4'
    interp: 6*baud_rate
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_agc_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_divide_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_rms_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_1, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_1, '1']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_eye_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_1, '2']
- [blocks_divide_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_divide_xx_0, '1']
- [blocks_float_to_complex_1, '0', digital_corr_est_cc_0, '0']
- [blocks_rms_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_rms_xx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0_0, print_pdu]
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_1_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_header_payload_demux_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_protocol_parser_b_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [digital_corr_est_cc_0, '1', qtgui_time_sink_x_1_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_file_sink_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_1, '0']
- [digital_header_payload_demux_0, '1', blocks_file_sink_1_1, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_0, '0']
- [digital_packet_headerparser_b_0, header_data, blocks_message_debug_0_0, print]
- [digital_protocol_parser_b_0, info, blocks_message_debug_0, print_pdu]
- [digital_protocol_parser_b_1, info, digital_header_payload_demux_0, header_data]
- [digital_symbol_sync_xx_0, '0', blocks_float_to_char_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_3, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1
