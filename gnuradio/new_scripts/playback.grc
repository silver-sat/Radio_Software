options:
  parameters:
    generate_options: qt_gui
    id: playback
    output_language: python
    title: ssdv envelope
  states: {}

blocks:
- name: CenterDiff
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: bit_time
  id: variable
  parameters:
    value: '.059'
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: 16*8
  states: {}
- name: packet_length
  id: variable
  parameters:
    value: 250*8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: oversample*symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/(2*decimate)/4
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      use this to move the start ahead.  
      since the sample rate of the wav file 
      is 153.6 samples/sec, move ahead by
      153600 * T, where T is the number of 
      seconds you wish to skip.
    num_items: int(samp_rate/decimate)*0
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/decimate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Script expects .wav source 
      captured at baseband.
    file: /home/tom/captures/20260108_005555.307107.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: capture_session_id
  id: parameter
  parameters:
    hide: part
    label: capture_session_id
    type: intx
    value: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nDoppler IQ Playback Block (Complex Output)\n------------------------------------------\n\nThis GNU Radio Embedded Python block plays back a stereo WAV file containing IQ samples\nand computes the Doppler-shifted satellite frequency difference relative to the SDR\ncenter frequency. It publishes the difference in sync with the playback once per second\nvia a message port.\n\nRequirements:\n    - Input WAV file must be stereo (2 channels).\n    - Left channel = I (in-phase) samples.\n    - Right channel = Q (quadrature) samples.\n    - WAV filename must contain a timestamp in the format: \"_HH-MM-SS_DD-MM-YYYY\"\n      for proper playback alignment.\n\nInputs:\n    None (reads directly from WAV file)\n\nOutputs:\n    One complex64 stream (I + jQ)\n\nMessage Ports:\n    \"freq\" → publishes center frequency difference (Hz)\n\nAuthor: Douglas C. Papay <k8dp.doug@gmail.com>\nLicense: GPLv3\n\nModified by Tom Conrad for use with Silversat_packets system\nAdds the ability to read in parameters from an SQLite database\nNeeds Parameter block in .grc script to pass the capture_session_id,\nwhich is a table in the database that holds the setup parameters\n\"\"\"\n\nimport numpy as np\nimport ephem\nimport datetime\nimport wave\nimport re\nimport pmt\nfrom gnuradio import gr\nimport zoneinfo   # Python 3.9+\nimport sqlite3 \n\nDB_PATH = \"/home/tom/silversat_packets/observations.db\"\n\nC = 299792458.0  # speed of light in m/s\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Doppler IQ Playback Block (Complex Output)\n\n    This block plays back a stereo WAV file containing IQ samples and computes\n    the Doppler-shifted satellite frequency relative to the SDR center frequency.\n    It publishes the difference in sync with the playback once per second via a \n    message port.\n\n    Output:\n        One complex64 stream (I + jQ)\n        \n    Message Ports:\n        \"freq\" → publishes center frequency difference (Hz)\n    \"\"\"\n\n    def __init__(self,\n                 wav_file=\"\",\n                 tle_file=\"\",\n                 catalog_number=0,\n                 sat_freq_hz=0.0,\n                 center_freq_hz=0.0,\n                 lat=\"\", lon=\"\", elev=0,\n                 capture_session_id=0,\n                 timezone=\"America/NewYork\",\n                 debug=True\n                 ):\n        \"\"\"\n        Initialize the Doppler IQ Playback block.\n\n        Opens the stereo WAV file if provided, sets up the observer location,\n        loads the satellite TLE by catalog number, and parses the start time\n        from the filename (local → UTC).\n\n        Args:\n            wav_file (str): Path to stereo WAV file containing IQ samples.\n            tle_file (str): Path to TLE file containing satellite orbital elements.\n            catalog_number (int): Satellite catalog number (e.g., 66909).\n            sat_freq_hz (float): Satellite nominal frequency in Hz.\n            center_freq_hz (float): SDR spectrum center frequency in Hz.\n            lat (str): Observer latitude.\n            lon (str): Observer longitude.\n            elev (float): Observer elevation in meters.\n            timezone (str): Local timezone for filename timestamps.\n            debug (bool): Enable debug prints.\n        \"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Doppler IQ Playback',\n            in_sig=None,\n            out_sig=[np.complex64]  # single complex output stream\n        )\n\n        # Register message output port\n        self.message_port_register_out(pmt.intern(\"freq\"))\n        \n        self.capture_session_id = capture_session_id\n        self.start_time_utc = 0\n        \n        if capture_session_id:\n            try: \n                conn = sqlite3.connect(DB_PATH) \n                cur = conn.cursor()\n                \n                capture_setup = db.execute(\"SELECT * FROM capture_session WHERE id = ?\", (capture_session_id,)).fetchone()\n                location_info = db.execute(\"SELECT * FROM location WHERE id = ?\", (capture_setup[\"location_id\"],)).fetchone()\n                satellite_info = db.execute(\"SELECT * FROM satellite WHERE id = ?\", (capture_setup[\"satellite_id\"],)).fetchone()\n                self.wav_file = capture_setup[\"lat_deg\"]\n                \n                # i'm not storing tle's in a file, so I can jump ahead to assigning them to variables\n                line1 = capture_setup[\"tle_line_1\"]\n                line2 = capture_setup[\"tle_line_2\"]\n                self.catalog_number = satellite_info[\"catalog_number\"]\n                self.sat_freq_hz = satellite_info[\"nominal_freq_hz\"]\n                self.center_freq_hz = capture_setup[\"center_freq_hz\"]\n                self.lat = location_info[\"lat_deg\"]\n                self.lon = location_info[\"lon_deg\"]\n                self.elev = location_info[\"elev_m\"]\n                self.timezone = capture_setup[\"observer_timezone\"]\n                self.start_time_utc = capture_setup[\"start_time_utc\"]\n                self.debug = debug\n                conn.close()\n                \n                parts = line1.split()\n                if len(parts) > 1:\n                    catnum = parts[1]  # e.g. \"66909U\"\n                    catnum_digits = ''.join(ch for ch in catnum if ch.isdigit())\n\n                    if catnum_digits == self.catalog_number:\n                        self.sat = ephem.readtle(name, line1, line2)\n                        if self.debug:\n                            print(f\"[DEBUG] Loaded satellite {name} with catalog {catnum_digits}\")\n                            print(\"[DEBUG] Line1:\", line1)\n                            print(\"[DEBUG] Line2:\", line2)\n\n                if self.sat is None and self.debug:\n                    print(f\"[DEBUG] Catalog number {self.catalog_number} not found in file\")\n                \n            except Exception as e: \n                print(f\"[doppler] DB error: {e}\")\n        else:\n            # Parameters\n            self.wav_file = wav_file\n            self.tle_file = tle_file\n            self.catalog_number = str(catalog_number)\n            self.sat_freq_hz = float(sat_freq_hz)\n            self.center_freq_hz = float(center_freq_hz)\n            self.lat = str(lat)\n            self.lon = str(lon)\n            self.elev = float(elev)\n            self.timezone = timezone\n            self.debug = debug\n\n        # Open WAV (only if provided)\n        self.wav = None\n        self.channels = 1\n        self.sample_rate = 1\n        if self.wav_file:\n            self.wav = wave.open(self.wav_file, 'rb')\n            self.channels = self.wav.getnchannels()\n            self.sample_rate = self.wav.getframerate()\n            print(f'wav file framerate: {self.wav.getframerate()}')\n\n            # Require stereo WAV file\n            if self.channels != 2:\n                raise ValueError(\n                    f\"WAV file {self.wav_file} must be stereo (2 channels), \"\n                    f\"but has {self.channels} channel(s).\"\n                )\n\n            if self.debug:\n                print(f\"[DEBUG] Opened WAV file: {self.wav_file}, \"\n                      f\"Channels: {self.channels}, SampleRate: {self.sample_rate}\")\n\n        # Observer setup\n        self.observer = ephem.Observer()\n        self.observer.lat = self.lat if self.lat else \"0\"\n        self.observer.lon = self.lon if self.lon else \"0\"\n        self.observer.elevation = self.elev\n\n        # Load TLE by catalog number\n        if capture_session_id == 0:\n            self.sat = None\n            if self.tle_file:\n                with open(self.tle_file, 'r') as f:\n                    lines = [ln.strip() for ln in f if ln.strip()]\n                total_sats = len(lines) // 3\n                if self.debug:\n                    print(f\"[DEBUG] TLE file has {total_sats} satellites\")\n\n                for i in range(total_sats):\n                    name  = lines[i*3]\n                    line1 = lines[i*3 + 1]\n                    line2 = lines[i*3 + 2]\n\n                    parts = line1.split()\n                    if len(parts) > 1:\n                        catnum = parts[1]  # e.g. \"66909U\"\n                        catnum_digits = ''.join(ch for ch in catnum if ch.isdigit())\n\n                        if catnum_digits == self.catalog_number:\n                            self.sat = ephem.readtle(name, line1, line2)\n                            if self.debug:\n                                print(f\"[DEBUG] Loaded satellite {name} with catalog {catnum_digits}\")\n                                print(\"[DEBUG] Line1:\", line1)\n                                print(\"[DEBUG] Line2:\", line2)\n                            break\n\n                if self.sat is None and self.debug:\n                    print(f\"[DEBUG] Catalog number {self.catalog_number} not found in file\")\n\n        if self.start_time_utc:\n            self.start_time = self.start_time_utc\n        else:\n            # Parse date/time from filename (local → UTC)\n            self.start_play = datetime.datetime.utcnow()  # fallback\n            match = re.search(r'_(\\d{2}-\\d{2}-\\d{2})_(\\d{2}-\\d{2}-\\d{4})', self.wav_file)\n            if match:\n                timestr, datestr = match.groups()\n                try:\n                    local_dt = datetime.datetime.strptime(\n                        timestr + \"_\" + datestr, \"%H-%M-%S_%d-%m-%Y\"\n                    )\n                    local_dt = local_dt.replace(tzinfo=zoneinfo.ZoneInfo(self.timezone))\n                    self.start_play = local_dt.astimezone(zoneinfo.ZoneInfo(\"UTC\"))\n                    if self.debug:\n                        print(\"[DEBUG] Parsed local time:\", local_dt)\n                        print(\"[DEBUG] Converted to UTC:\", self.start_play)\n                except ValueError:\n                    if self.debug:\n                        print(\"[DEBUG] Failed to parse start time, using UTC fallback\")\n\n        # Local variables\n        self.sample_counter = 0\n        self.next_update = 0\n\n    def work(self, input_items, output_items):\n        \"\"\"\n        Process audio samples and compute frequency difference.\n\n        Reads frames from the stereo WAV file, outputs complex IQ stream,\n        and once per second computes the Doppler-shifted satellite frequency\n        relative to the SDR center frequency. Publishes the difference via\n        the \"freq\" message port.\n\n        Args:\n            input_items (list): Input streams (unused).\n            output_items (list): Output stream (complex IQ samples).\n\n        Returns:\n            int: Number of output items produced, or -1 if end of file.\n        \"\"\"\n        out = output_items[0]\n        n = len(out)\n\n        # Audio playback\n        if self.wav is not None:\n            frames = self.wav.readframes(n)\n            \n            if not frames:\n                out[:] = 0.0 + 0.0j\n                return -1\n            data = np.frombuffer(frames, dtype=np.float32) #.astype(np.float32)\n\n            # Stereo IQ required\n            stereo = data.reshape(-1, 2)\n            # i_data = stereo[:, 0] / 2147483648.0\n            # q_data = stereo[:, 1] / 2147483648.0\n            i_data = stereo[:, 0]\n            q_data = stereo[:, 1]\n            \n            iq = i_data[:n] + 1j * q_data[:n]\n            if len(iq) < n:\n                iq = np.pad(iq, (0, n - len(iq)), constant_values=0)\n            out[:] = iq\n        else:\n            out[:] = 0.0 + 0.0j\n        \n        \n        # Advance sample counter\n        self.sample_counter += n\n\n        # Center difference calculation once per second\n        if self.sat is not None and self.sat_freq_hz > 0.0 and self.center_freq_hz > 0.0:\n            if self.sample_counter >= self.next_update:\n                current_dt = self.start_play + datetime.timedelta(\n                    seconds=self.sample_counter / self.sample_rate\n                )\n                self.observer.date = current_dt\n                self.sat.compute(self.observer)\n                rel_vel = self.sat.range_velocity\n\n                # Doppler-shifted satellite frequency\n                sat_doppler_freq = self.sat_freq_hz * (1 - rel_vel / C)\n\n                # Difference to SDR center\n                center_diff = sat_doppler_freq - self.center_freq_hz\n\n                if self.debug:\n                    print(f\"[DEBUG] Time: {current_dt}, RelVel: {rel_vel:.2f} m/s, \"\n                          f\"SatFreq+Doppler: {sat_doppler_freq:.2f} Hz, \"\n                          f\"CenterDiff: {center_diff:.2f} Hz\")\n\n                # Publish only the center difference value via \"freq\" port\n                self.message_port_pub(\n                    pmt.intern(\"freq\"),\n                    pmt.cons(pmt.intern(\"center_diff\"),\n                             pmt.from_double(center_diff))\n                )\n\n                # Schedule next update one second later\n                self.next_update += self.sample_rate\n\n        return n\n\n"
    capture_session_id: '0'
    catalog_number: '66909'
    center_freq_hz: freq
    debug: 'True'
    elev: '2'
    lat: '38.9830'
    lon: '-76.4830'
    sat_freq_hz: freq
    timezone: '''America/NewYork'''
    tle_file: '"/home/tom/passdata/silversat_18-12-2025.tle"'
    wav_file: source_file
  states: {}
- name: freq
  id: parameter
  parameters:
    label: center_freq
    type: eng_float
    value: '437175000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimate
    samp_rate: samp_rate/decimate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5/bit_time
    decim: '100'
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_fff
    width: '5'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    size: 1024*50
    srate: samp_rate/decimate/100
    tr_level: '0.01'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: int(samp_rate/decimate)
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: source_file
  id: parameter
  parameters:
    label: source_file
    type: str
    value: /home/tom/captures/20260107_021501.448136.wav
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_skiphead_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_skiphead_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_selector_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', blocks_selector_0, '1']
- [epy_block_0, freq, blocks_message_debug_0, log]
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
